# IAR project usbh_hid.ewp, settings and files
configuration USBFS (ARM, debug)
  General.OGChipSelectEditMenu: GD32F503xG GD GD32F503xG
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 59
  General.FPU2: 0
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; USE_USB_FS; GD32F50X; USE_LCD
  ICCARM.CCIncludePath2: ..\inc; ..\..\..\..\..\GD32F50x_Firmware_Library\CMSIS\GD\GD32F50x\Include; ..\..\..\..\..\GD32F50x_Firmware_Library\GD32F50x_standard_peripheral\Include; ..\..\..\..\..\GD32F50x_Firmware_Library\GD32F50x_usbfs_library\driver\Include; ..\..\..\..\..\GD32F50x_Firmware_Library\GD32F50x_usbfs_library\host\class\hid\Include; ..\..\..\..\..\GD32F50x_Firmware_Library\GD32F50x_usbfs_library\host\core\Include; ..\..\..\..\..\GD32F50x_Firmware_Library\GD32F50x_usbfs_library\ustd\common; ..\..\..\..\..\GD32F50x_Firmware_Library\GD32F50x_usbfs_library\ustd\class\hid
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: USBH_HID.srec
  ILINK.IlinkOutputFile: usbh_hid.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application
    ../src/: gd32f50x_it.c gd32f50x_usb_hw.c main.c usbh_usr.c usbh_usr_lcd.c
  group CMSIS
    ../../../../../GD32F50x_Firmware_Library/CMSIS/GD/GD32F50x/Source/: gd32f50x_err_report.c
    ../src/: system_gd32f50x.c
  group Doc
    ../: readme.txt
  group GD32F50x_EVAL
    ../src/: gd32f503v_eval.c gd32f50x_lcd_eval.c lcd_font.c lcd_log.c
  group GD32F50x_Peripherals
    ../../../../../GD32F50x_Firmware_Library/GD32F50x_standard_peripheral/Source/: gd32f50x_exmc.c gd32f50x_exti.c gd32f50x_fmc.c gd32f50x_gpio.c gd32f50x_misc.c gd32f50x_pmu.c gd32f50x_rcu.c gd32f50x_syscfg.c gd32f50x_timer.c gd32f50x_usart.c
  group Startup
    ../../../../../GD32F50x_Firmware_Library/CMSIS/GD/GD32F50x/Source/IAR/: startup_gd32f50x.s
  group USB_Class
    ../../../../../GD32F50x_Firmware_Library/GD32F50x_usbfs_library/host/class/hid/Source/: usbh_hid_core.c usbh_standard_hid.c
  group USB_Drivers
    ../../../../../GD32F50x_Firmware_Library/GD32F50x_usbfs_library/driver/Source/: drv_usb_core.c drv_usb_host.c drv_usbh_int.c
  group USB_Host
    ../../../../../GD32F50x_Firmware_Library/GD32F50x_usbfs_library/host/core/Source/: usbh_core.c usbh_enum.c usbh_pipe.c usbh_transc.c
