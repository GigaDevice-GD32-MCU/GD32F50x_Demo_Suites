# Keil uVision project hid_keyboard.uvprojx, settings and files
target hid_keyboard (6130001::V6.13.1::.\ARMCLANG)
  device: GD32F503VG GigaDevice
  pack: GigaDevice.GD32F50x_DFP.0.0.2
  cpu: IRAM(0x20000000,0x018000) IROM(0x08000000,0x0100000) CPUTYPE("Cortex-M33") FPU3(SFPU) CLOCK(12000000) ELITTLE
  output: hid_keyboard +hex
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_STDPERIPH_DRIVER,USE_USB_FS,GD32F50X
  c include: ..\inc;..\..\..\..\..\GD32F50x_Firmware_Library\CMSIS\GD\GD32F50x\Include;..\..\..\..\..\GD32F50x_Firmware_Library\GD32F50x_standard_peripheral\Include;..\..\..\..\..\GD32F50x_Firmware_Library\GD32F50x_usbfs_library\driver\Include;..\..\..\..\..\GD32F50x_Firmware_Library\GD32F50x_usbfs_library\device\core\Include;..\..\..\..\..\GD32F50x_Firmware_Library\GD32F50x_usbfs_library\device\class\hid\Include;..\..\..\..\..\GD32F50x_Firmware_Library\GD32F50x_usbfs_library\ustd\common;..\..\..\..\..\GD32F50x_Firmware_Library\GD32F50x_usbfs_library\ustd\class\hid;..\..\..\..\Utilities
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x18000
  group Application
    ../src/: app.c gd32f50x_it.c gd32f50x_hw.c hid_keyboard_itf.c
  group CMSIS
    ../src/: system_gd32f50x.c
    ../../../../../GD32F50x_Firmware_Library/CMSIS/GD/GD32F50x/Source/: gd32f50x_err_report.c
  group GD32F50x_StdPeriph_Driver
    ../../../../../GD32F50x_Firmware_Library/GD32F50x_standard_peripheral/Source/: gd32f50x_exti.c gd32f50x_gpio.c gd32f50x_misc.c gd32f50x_pmu.c gd32f50x_rcu.c gd32f50x_timer.c gd32f50x_usart.c gd32f50x_fmc.c gd32f50x_syscfg.c
  group GD32F50x_EVAL
    ../../../../Utilities/: gd32f503v_eval.c
  group USB_Drivers
    ../../../../../GD32F50x_Firmware_Library/GD32F50x_usbfs_library/driver/Source/: drv_usb_core.c drv_usb_dev.c drv_usbd_int.c
  group USB_Device
    ../../../../../GD32F50x_Firmware_Library/GD32F50x_usbfs_library/device/core/Source/: usbd_core.c usbd_enum.c usbd_transc.c
  group USB_Class
    ../../../../../GD32F50x_Firmware_Library/GD32F50x_usbfs_library/device/class/hid/Source/: standard_hid_core.c
  group Startup
    ../../../../../GD32F50x_Firmware_Library/CMSIS/GD/GD32F50x/Source/ARM/: startup_gd32f50x.s
  group Doc
    ../: readme.txt
software components: CMSIS:CORE 5.3.0
