# Keil uVision project usbh_msc.uvprojx, settings and files
target usbh_msc (6130001::V6.13.1::.\ARMCLANG)
  device: GD32F503VG GigaDevice
  pack: GigaDevice.GD32F50x_DFP.0.0.2
  cpu: IRAM(0x20000000,0x018000) IROM(0x08000000,0x0100000) CPUTYPE("Cortex-M33") FPU3(SFPU) CLOCK(12000000) ELITTLE
  output: usbh_msc +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_STDPERIPH_DRIVER,USE_USB_FS,GD32F50X,USE_LCD
  c include: ..\inc;..\..\..\..\..\GD32F50x_Firmware_Library\CMSIS\GD\GD32F50x\Include;..\..\..\..\..\GD32F50x_Firmware_Library\GD32F50x_standard_peripheral\Include;..\..\..\..\..\GD32F50x_Firmware_Library\GD32F50x_usbfs_library\driver\Include;..\..\..\..\..\GD32F50x_Firmware_Library\GD32F50x_usbfs_library\host\core\Include;..\..\..\..\..\GD32F50x_Firmware_Library\GD32F50x_usbfs_library\host\class\msc\Include;..\..\..\..\..\GD32F50x_Firmware_Library\GD32F50x_usbfs_library\ustd\common;..\..\..\..\..\GD32F50x_Firmware_Library\GD32F50x_usbfs_library\ustd\class\msc;..\..\..\..\Utilities\Third_Party\fat_fs\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x18000
  group Application
    ../src/: main.c usbh_usr.c gd32f50x_it.c gd32f50x_usb_hw.c
  group CMSIS
    ../src/: system_gd32f50x.c
    ../../../../../GD32F50x_Firmware_Library/CMSIS/GD/GD32F50x/Source/: gd32f50x_err_report.c
  group GD32F50x_StdPeriph_Driver
    ../../../../../GD32F50x_Firmware_Library/GD32F50x_standard_peripheral/Source/: gd32f50x_exmc.c gd32f50x_exti.c gd32f50x_gpio.c gd32f50x_misc.c gd32f50x_pmu.c gd32f50x_rcu.c gd32f50x_timer.c gd32f50x_usart.c gd32f50x_fmc.c gd32f50x_syscfg.c
  group GD32F50x_EVAL
    ../src/: gd32f50x_lcd_eval.c gd32f503v_eval.c lcd_font.c lcd_log.c
  group USB_Driver
    ../../../../../GD32F50x_Firmware_Library/GD32F50x_usbfs_library/driver/Source/: drv_usb_core.c drv_usb_host.c drv_usbh_int.c
  group USB_Host
    ../../../../../GD32F50x_Firmware_Library/GD32F50x_usbfs_library/host/core/Source/: usbh_core.c usbh_enum.c usbh_pipe.c usbh_transc.c
  group USB_Class
    ../../../../../GD32F50x_Firmware_Library/GD32F50x_usbfs_library/host/class/msc/Source/: usbh_msc_bbb.c usbh_msc_core.c usbh_msc_fatfs.c usbh_msc_scsi.c
  group Startup
    ./: startup_gd32f50x.s
  group FAT_FS
    ../../../../Utilities/Third_Party/fat_fs/src/: ff.c ffunicode.c
  group Doc
    ../: readme.txt
software components: CMSIS:CORE 5.3.0
