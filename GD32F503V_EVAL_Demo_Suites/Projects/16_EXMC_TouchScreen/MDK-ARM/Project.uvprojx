# Keil uVision project Project.uvprojx, settings and files
target GD32F503V_EVAL (6140000::V6.14::ARMCLANG)
  device: GD32F503VG GigaDevice
  pack: GigaDevice.GD32F50x_DFP.0.0.5
  cpu: IRAM(0x20000000,0x018000) IROM(0x08000000,0x0100000) CPUTYPE("Cortex-M33") FPU3(SFPU) CLOCK(12000000) ELITTLE
  output: Project
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_STDPERIPH_DRIVER, GD32F50X, GD32F503, FW_DEBUG_ERR_REPORT
  c include: ..\..\..\..\GD32F50x_Firmware_Library\CMSIS\GD\GD32F50x\Include;..\..\..\..\GD32F50x_Firmware_Library\CMSIS;..\..\..\..\GD32F50x_Firmware_Library\GD32F50x_standard_peripheral\Include;..\..\..\Utilities;..\;..\Soft_Drive;..\..\..\Utilities\LCD_Commom
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x18000
  group Application
    ../: main.c systick.c gd32f50x_it.c
  group CMSIS
    ../../../../GD32F50x_Firmware_Library/CMSIS/GD/GD32F50x/Source/: system_gd32f50x.c gd32f50x_err_report.c
  group GD32F50x_Peripherals
    ../../../../GD32F50x_Firmware_Library/GD32F50x_standard_peripheral/Source/: gd32f50x_adc.c gd32f50x_bkp.c gd32f50x_can.c gd32f50x_cau.c gd32f50x_cmp.c gd32f50x_crc.c gd32f50x_ctc.c gd32f50x_dac.c gd32f50x_dbg.c gd32f50x_dma.c gd32f50x_exmc.c gd32f50x_exti.c gd32f50x_fmc.c gd32f50x_fwdgt.c gd32f50x_gpio.c gd32f50x_hau.c gd32f50x_i2c.c gd32f50x_misc.c gd32f50x_pmu.c gd32f50x_rcu.c gd32f50x_rtc.c gd32f50x_spi.c gd32f50x_syscfg.c gd32f50x_timer.c gd32f50x_trigsel.c gd32f50x_trng.c gd32f50x_usart.c gd32f50x_wwdgt.c
  group GD32F50x_EVAL
    ../../../Utilities/: gd32f503v_eval.c gd32f503v_lcd_eval.c
  group Soft_Drive
    ../Soft_Drive/: picture.c touch_panel.c
  group Startup
    ../../../../GD32F50x_Firmware_Library/CMSIS/GD/GD32F50x/Source/ARM/: startup_gd32f50x.s
  group Doc
    ../: readme.txt
software components: CMSIS:CORE 5.3.0
