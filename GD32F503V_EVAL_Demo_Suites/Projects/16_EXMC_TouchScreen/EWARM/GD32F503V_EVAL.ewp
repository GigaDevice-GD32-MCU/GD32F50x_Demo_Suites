# IAR project GD32F503V_EVAL.ewp, settings and files
configuration GD32F50x (ARM)
  General.OGChipSelectEditMenu: GD32F503xG GD GD32F503xG
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 59
  General.FPU2: 6
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; GD32F50X; GD32F503; FW_DEBUG_ERR_REPORT
  ICCARM.CCIncludePath2: ..\..\..\..\GD32F50x_Firmware_Library\CMSIS\GD\GD32F50x\Include; ..\..\..\Utilities; ..; ..\..\..\..\GD32F50x_Firmware_Library\GD32F50x_standard_peripheral\Include; ..\..\..\..\GD32F50x_Firmware_Library\CMSIS\GD\GD32F50x\Include; ..\Soft_Drive; ..\..\..\Utilities\LCD_Commom
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Project.srec
  ILINK.IlinkOutputFile: Project.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application
    ../: gd32f50x_it.c main.c systick.c
  group CMSIS
    ../../../../GD32F50x_Firmware_Library/CMSIS/GD/GD32F50x/Source/: gd32f50x_err_report.c system_gd32f50x.c
  group Doc
    ../: readme.txt
  group GD32F50x_EVAL
    ../../../Utilities/: gd32f503v_eval.c gd32f503v_lcd_eval.c
  group GD32F50x_Peripherals
    ../../../../GD32F50x_Firmware_Library/GD32F50x_standard_peripheral/Source/: gd32f50x_adc.c gd32f50x_bkp.c gd32f50x_can.c gd32f50x_cau.c gd32f50x_cmp.c gd32f50x_crc.c gd32f50x_ctc.c gd32f50x_dac.c gd32f50x_dbg.c gd32f50x_dma.c gd32f50x_exmc.c gd32f50x_exti.c gd32f50x_fmc.c gd32f50x_fwdgt.c gd32f50x_gpio.c gd32f50x_hau.c gd32f50x_i2c.c gd32f50x_misc.c gd32f50x_pmu.c gd32f50x_rcu.c gd32f50x_rtc.c gd32f50x_spi.c gd32f50x_syscfg.c gd32f50x_timer.c gd32f50x_trigsel.c gd32f50x_trng.c gd32f50x_usart.c gd32f50x_wwdgt.c
  group Soft_Drive
    ../Soft_Drive/: picture.c touch_panel.c
  group Startup
    ../../../../GD32F50x_Firmware_Library/CMSIS/GD/GD32F50x/Source/IAR/: startup_gd32f50x.s
